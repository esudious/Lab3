# Keil uVision project Lab2.uvprojx, settings and files
target Lab2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source Code
    ./: Startup.s main.s
    ../: tm4c123gh6pm.s
    D:/EE319Kware/inc/: tm4c123gh6pm.h
    D:/EE319Kware/InputOutput_4C123/: texas.o
    ../C8_Security/: TExaS.h
software components: CMSIS:CORE 5.0.0
